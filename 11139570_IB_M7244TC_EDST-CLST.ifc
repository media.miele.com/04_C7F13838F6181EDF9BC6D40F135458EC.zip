Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 54aa49ae-64c7-48e4-8d52-c84394c871cd, NumberOfSaves: 1]
File name: 0001
Time: 2024-09-05T12:29:01+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11139570_IB_M7244TC_EDST-CLST:24724440_IB_11139570_M7244TC_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, <Unnamed>, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm; Depth: 560 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 24724440_IB_11139570_M7244TC_EDST-CLST; sets with these values: 2

# IfcDistributionPort, Port_353641_1
Description: Flow; FlowDirection: SOURCEANDSINK
